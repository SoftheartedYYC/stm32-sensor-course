# Keil uVision project Framework.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Framework +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\STM32F10x_FWLib\inc;..\USER;..\CORE;..\APP\bh1750;..\APP\buzzer;..\APP\dht11;..\APP\ds18b20;..\APP\key;..\APP\led;..\APP\matrixkey;..\APP\oled;..\APP\photo;..\APP\relay;..\APP\stepper;..\APP\rgb;..\APP\smg;..\APP\interrupt;..\APP\hcsr04;..\APP\iic
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c main.h stm32f10x_it.c system_stm32f10x.c
  group APP
    ../APP/bh1750/: bh1750.c
    ../APP/hcsr04/: hcsr04.c
    ../APP/iic/: iic.c
    ../APP/buzzer/: buzzer_app.c
    ../APP/interrupt/: buzzer_irq.c tick_irq.c soft_timer.c key_irq.c matrix_irq.c
    ../APP/dht11/: dht11_app.c
    ../APP/ds18b20/: ds18b20_app.c
    ../APP/key/: key_app.c
    ../APP/led/: led_app.c
    ../APP/matrixkey/: matrixkey.c
    ../APP/oled/: oled_app.c oled_font.c
    ../APP/photo/: photo_app.c
    ../APP/relay/: relay_app.c
    ../APP/stepper/: stepper_app.c
    ../APP/rgb/: rgb_app.c
    ../APP/smg/: smg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group STM32F10x_FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
